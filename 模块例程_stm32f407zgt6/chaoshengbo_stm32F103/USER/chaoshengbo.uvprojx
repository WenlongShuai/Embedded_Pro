# Keil uVision project chaoshengbo.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: chaoshengbo
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CODE;..\FWLIB\inc;..\HARDWARE\HC_SR04;..\HARDWARE\TIMER;..\SYSTEM\delay;..\SYSTEM\systick;..\SYSTEM\usart;..\USER;..\HARDWARE\OLED;..\HARDWARE\SOFTWARE_I2C
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CODE
    ../CODE/: core_cm3.c
    ../CODE/startup/: startup_stm32f10x_md.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/systick/: SysTick.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/HC_SR04/: HC_SR04.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SOFTWARE_I2C/: software_iic.c
    ../HARDWARE/OLED/: oled.c oled_codetab.h
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
