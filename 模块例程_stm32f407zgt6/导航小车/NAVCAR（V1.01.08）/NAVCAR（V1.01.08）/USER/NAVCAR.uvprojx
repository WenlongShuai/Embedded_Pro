# Keil uVision project NAVCAR.uvprojx, settings and files
target NAVCAR (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NAVCAR +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\HARDWARE\GPS;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\USART3;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USMART;..\USER;..\HARDWARE\TIMER7;..\HARDWARE\IIC;..\HARDWARE\PRESS;..\HARDWARE\SIM;..\HARDWARE\TIMER3;..\HARDWARE\USART2;..\HARDWARE\WIFI;..\HARDWARE\YAW;..\HARDWARE\USART6;..\HARDWARE\PWM;..\HARDWARE\FUN;..\HARDWARE\PID;..\HARDWARE\FILTER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group HARDWARE
    ../HARDWARE/GPS/: gps.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/TIMER7/: timer7.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/PRESS/: press.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/TIMER3/: timer3.c
    ../HARDWARE/WIFI/: wifi.c
    ../HARDWARE/YAW/: yaw.c
    ../HARDWARE/USART6/: usart6.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/FUN/: fun.c
    ../HARDWARE/FILTER/: filter.c
    ../HARDWARE/SIM/: sim.c
