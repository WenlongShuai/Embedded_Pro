# Keil uVision project ATK_MS53L1M_Template.uvprojx, settings and files
target ATK_MS53L1M_Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MG90S +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CODE;..\FWLIB\inc;..\HARDWARE\OLED;..\HARDWARE\SOFTWARE_I2C;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\HARDWARE_I2C;..\HARDWARE\ATK_MS53L1M;..\HARDWARE\ATK_MS53L1M\VL53L1X\Api\core\inc;..\HARDWARE\ATK_MS53L1M\VL53L1X\Api\platform\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/SOFTWARE_I2C/: software_iic.c
    ../HARDWARE/HARDWARE_I2C/: hardware_iic.c
  group CODE
    ../CODE/: core_cm3.c
    ../CODE/startup/: startup_stm32f10x_md.s
  group ATK_MS53L1M
    ../HARDWARE/ATK_MS53L1M/: atk_ms53l1m.c atk_ms53l1m_iic.c
    ../HARDWARE/ATK_MS53L1M/VL53L1X/Api/core/src/: vl53l1_api.c vl53l1_api_calibration.c vl53l1_api_core.c vl53l1_api_debug.c vl53l1_api_preset_modes.c vl53l1_api_strings.c vl53l1_core.c vl53l1_core_support.c vl53l1_error_strings.c vl53l1_register_funcs.c vl53l1_silicon_core.c vl53l1_wait.c
    ../HARDWARE/ATK_MS53L1M/VL53L1X/Api/platform/src/: vl53l1_i2c_platform.c vl53l1_platform.c
