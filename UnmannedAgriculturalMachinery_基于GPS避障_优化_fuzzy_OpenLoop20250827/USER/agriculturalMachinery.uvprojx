# Keil uVision project agriculturalMachinery.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: agriculturalMachinery +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\CODE;..\FWLIB\inc;..\HARDWARE\HARDWARE_I2C;..\HARDWARE\HC_SR04;..\HARDWARE\HI600D;..\HARDWARE\SOFTWARE_I2C;..\HARDWARE\W25Qxx;..\SYSTEM\sys;..\SYSTEM\systick;..\SYSTEM\usart;..\USER;..\SYSTEM\delay;..\HARDWARE\TRACK;..\HARDWARE\OLED;..\HARDWARE\TIMER;..\HARDWARE\bluetooth;..\HARDWARE\PROTOCOL;..\HARDWARE\PID_USART;..\HARDWARE\JY901P;..\HARDWARE\JY901P_USART;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\HARDWARE\FuzzyDecision;..\HARDWARE\Motor;..\HARDWARE\Motor_PID;..\HARDWARE\FUN;..\HARDWARE\ATK_MS53L1M;..\HARDWARE\ATK_MS53L1M\VL53L1X\Api\core\inc;..\HARDWARE\ATK_MS53L1M\VL53L1X\Api\platform\inc;..\HARDWARE\LCD;..\HARDWARE\BigCarMotorControl;..\HARDWARE\KEY
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CODE
    ../CODE/: startup_stm32f40_41xxx.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group HAEDWARE
    ../HARDWARE/HARDWARE_I2C/: hardware_iic.c
    ../HARDWARE/HC_SR04/: hc_sr04.c
    ../HARDWARE/HI600D/: hi600.c
    ../HARDWARE/SOFTWARE_I2C/: software_iic.c
    ../HARDWARE/W25Qxx/: w25qxx.c
    ../HARDWARE/TRACK/: track.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/bluetooth/: bluetooth.c
    ../HARDWARE/PROTOCOL/: protocol.c
    ../HARDWARE/TIMER/: timing_fun.c
    ../HARDWARE/PID_USART/: pid_usart.c
    ../HARDWARE/JY901P/: jy901p.c
    ../HARDWARE/JY901P_USART/: jy901p_usart.c
    ../HARDWARE/FuzzyDecision/: fuzzy_decision.c
    ../HARDWARE/Motor_PID/: motor_PID.c
    ../HARDWARE/Motor/: motor.c
    ../HARDWARE/FUN/: fun.c
    ../HARDWARE/LCD/: GUI.c lcd_ili9341.c
    ../HARDWARE/BigCarMotorControl/: bigCarMotorControl.c
    ../HARDWARE/KEY/: key.c
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c freeRTOS_TaskList.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORT
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group ATK_MS53L1M
    ../HARDWARE/ATK_MS53L1M/: atk_ms53l1m.c atk_ms53l1m_iic.c
    ../HARDWARE/ATK_MS53L1M/VL53L1X/Api/core/src/: vl53l1_api.c vl53l1_api_calibration.c vl53l1_api_core.c vl53l1_api_debug.c vl53l1_api_preset_modes.c vl53l1_api_strings.c vl53l1_core.c vl53l1_core_support.c vl53l1_error_strings.c vl53l1_register_funcs.c vl53l1_silicon_core.c vl53l1_wait.c
    ../HARDWARE/ATK_MS53L1M/VL53L1X/Api/platform/src/: vl53l1_i2c_platform.c vl53l1_platform.c
