# Keil uVision project LCD.uvprojx, settings and files
target LCD (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CLOCK(12000000) FPU3(SFPU) ELITTLE CPUTYPE("Cortex-M7")
  output: LCD
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;              ../Drivers/STM32F7xx_HAL_Driver/Inc;              ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;              ../Drivers/CMSIS/Include;              ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;              ..\Src\ILI9341
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f7xx_it.c main.c spi.c usart.c gpio.c stm32f7xx_hal_msp.c rng.c tim.c
    ../Src/ILI9341/: ILI9341_GFX.c ILI9341_STM32_Driver.c ILI9341_Touchscreen.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_rcc.c stm32f7xx_hal_flash.c stm32f7xx_hal_cortex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_dma.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_tim.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_rng.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
software components: CMSIS:CORE 4.1.0
