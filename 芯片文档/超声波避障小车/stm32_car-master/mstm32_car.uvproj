# Keil uVision project mstm32_car.uvproj, settings and files
target mstm32_car (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: mstm32_car +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_FULL_ASSERT,HSE_VALUE=8000000
  c misc: --c99
  c include: .\library\inc;.\startup;.\user
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./user/: main.c stm32f4xx_it.c stm32f4xx_it.h main.h motor.c motor.h itm.h usart.c usart.h sonar.h sonar.c delay.c delay.h fuzzy_decision.c fuzzy_decision.h servo.c servo.h pid.c pid.h
  group LIB
    ./library/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c misc.c stm32f4xx_usart.c
  group STARTUP
    ./startup/: startup_stm32f40_41xxx.s system_stm32f4xx.c stm32f4xx.h
